# Keil uVision project lab6.uvprojx, settings and files
target Target 1 (6070000::V6.7::.\ARMCLANG)
  device: MKL25Z128xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.13.0
  cpu: IRAM(0x1FFFF000,0x00004000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: lab1
  c flags: Optim=6 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group Source Group 1
    ./src/: GPIO.c main.c PIT.c TPM_PWM.c
software components: CMSIS:CORE 5.0.2, CMSIS:RTOS:Keil RTX5 5.2.0, CMSIS:RTOS2:Keil RTX5 5.2.0, Device:Startup 2.5.0
